# Keil uVision project stdPrj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G457REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stdPrj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: .\firmware\n32g45x_std_periph_driver\inc;.\firmware\CMSIS\core;.\firmware\CMSIS\device;.\user\inc;.\user;.\bsp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ./firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ./firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ./firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c
  group USER
    ./user/src/: main.c n32g45x_it.c Drv_led.c
    ./user/inc/: main.h n32g45x_it.h Drv_led.h
  group BSP
    ./bsp/: bsp_systick.c bsp_systick.h bsp_task.h bsp_task.c bsp_Delay.c bsp_Delay.h bsp_pwm.c bsp_pwm.h bsp_gpio.c bsp_gpio.h
